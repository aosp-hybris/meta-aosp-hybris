include android-headers.inc

SRCBRANCH ??= "hybris-4.2.2_r1"
SRCREV ?= "${AUTOREV}"
PV = "4.2.2+gitr${SRCPV}"
