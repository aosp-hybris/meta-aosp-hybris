require android-headers

SRCBRANCH ??= "hybris-4.4.2_r1"
SRCREV ?= "${AUTOREV}"
PV = "4.4.2+gitr${SRCPV}"
