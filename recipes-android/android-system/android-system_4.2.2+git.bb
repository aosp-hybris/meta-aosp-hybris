require ${BPN}.inc

SRCBRANCH = "hybris-4.2.2_r1"

COMPATIBLE_MACHINE = "goldfisharmv7|goldfishx86"

ANDROID_LUNCH_COMBO_goldfisharmv7 = "full-eng"
ANDROID_DEVICE_goldfisharmv7 = "goldfish"

ANDROID_LUNCH_COMBO_goldfishx86 = "full_x86-eng"
ANDROID_DEVICE_goldfishx86 = "goldfish"
