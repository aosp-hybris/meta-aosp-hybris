require android-system-image.inc

SRCBRANCH = "hybris-4.2.2_r1"

COMPATIBLE_MACHINE = "emulator|emulator-x86"

ANDROID_LUNCH_COMBO_emulator = "full-eng"
ANDROID_DEVICE_emulator = "goldfish"

ANDROID_LUNCH_COMBO_emulator-x86 = "full_x86-eng"
ANDROID_DEVICE_emulator-x86 = "goldfish"
