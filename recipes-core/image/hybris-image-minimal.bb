DESCRIPTION = "Minimal image to testing libhybris"

inherit core-image

IMAGE_INSTALL += "libhybris"

# TODO: Add basic android-system-image and config
